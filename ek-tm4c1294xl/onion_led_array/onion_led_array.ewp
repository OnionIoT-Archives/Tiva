# IAR project onion_led_array.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\onionlib; ..\..; ..\..\third_party\lwip-1.4.1\apps; ..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\third_party\lwip-1.4.1\src\include; ..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\third_party
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..; ..\onionlib; ..\..\third_party\lwip-1.4.1\apps; ..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\third_party\lwip-1.4.1\src\include; ..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\third_party
  OBJCOPY.OOCOutputFile: onion_led_array.bin
  ILINK.IlinkOutputFile: onion_led_array.out
  ILINK.IlinkIcfFile: onion_led_array.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../driverlib/ewarm/Exe/: driverlib.a
    ../onionlib/ewarm/Exe/: onionlib.a
  group Source
    ./: main.cpp startup_ewarm.c
    ../drivers/: pinout.c
    ../../utils/: uartstdio.c
