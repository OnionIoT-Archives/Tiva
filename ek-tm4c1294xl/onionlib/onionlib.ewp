# IAR project onionlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0; LWIP_1_4_1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..; ..\..\third_party\lwip-1.4.1\apps; ..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\third_party\lwip-1.4.1\src\include; ..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\third_party
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: onionlib.srec
  ILINK.IlinkOutputFile: onionlib.out
  group Libraries
    ../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../drivers/: eth_client_lwip.c
    ../../utils/: lwiplib.c
    ./: OnionClient.cpp OnionPacket.cpp OnionPayloadData.cpp OnionPayloadPacker.cpp
